options:
  parameters:
    generate_options: qt_gui
    id: sdv
    output_language: python
    title: asdf
  states: {}

blocks:
- name: ZC_ROOT
  id: variable
  parameters:
    value: '25'
  states: {}
- name: chan_num
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: (dspcore.FFT_SAMP_RATE) * (-7.5 + chan_num)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '30.72e6 '
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 1.9e6/2
    gain: '1.0'
    samp_rate: samp_rate
    width: 250e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/1000
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: dspcore.generate_tx_samples(0,25)
  states: {}
- name: eventhubs_ofdm_demod_0
  id: eventhubs_ofdm_demod
  parameters:
    threshold: '0.35'
  states: {}
- name: eventhubs_zc_detector_0
  id: eventhubs_zc_detector
  parameters:
    chan_idx: '0'
    threshold: '0.35'
    zc_root: '25'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: np.conjugate(dspcore.gen_ZC(25))[::-1]
    type: ccc
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: freq_offset
    decim: '16'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '16'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import dspcore
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/16
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '256'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/16
    fc: '0'
    fftsize: '256'
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [eventhubs_ofdm_demod_0, '0', qtgui_const_sink_x_0, '0']
- [eventhubs_ofdm_demod_0, freq, freq_xlating_fir_filter_xxx_0, freq]
- [eventhubs_zc_detector_0, detections, blocks_message_debug_0, print]
- [eventhubs_zc_detector_0, detections, eventhubs_ofdm_demod_0, detections]
- [fft_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [fft_filter_xxx_0, '0', eventhubs_zc_detector_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', fft_filter_xxx_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', eventhubs_ofdm_demod_0, '0']

metadata:
  file_format: 1

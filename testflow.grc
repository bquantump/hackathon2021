options:
  parameters:
    generate_options: qt_gui
    id: sdv
    output_language: python
    title: asdf
  states: {}

blocks:
- name: lpftaps
  id: variable
  parameters:
    value: '[4.5617685827892274e-05,4.5075368689140305e-05,4.2839470552280545e-05,3.8986032450338826e-05,3.365090742590837e-05,2.702515121200122e-05,1.9348311980138533e-05,1.0899972949118819e-05,1.989800921364804e-06,-7.053566605463857e-06,-1.5894376701908186e-05,-2.4201965061365627e-05,-3.166286478517577e-05,-3.799239493673667e-05,-4.294529207982123e-05,-4.632502168533392e-05,-4.799141606781632e-05,-4.786629506270401e-05,-4.593699850374833e-05,-4.225744123687036e-05,-3.69468834833242e-05,-3.0186249205144122e-05,-2.2212188923731446e-05,-1.3309011592355091e-05,-3.798832949541975e-06,5.9698168115573935e-06,1.563448313390836e-05,2.4831948394421488e-05,3.32115960191004e-05,4.044852903462015e-05,4.625586370821111e-05,5.039593088440597e-05,5.268970562610775e-05,5.302433419274166e-05,5.1358292694203556e-05,4.7724039177410305e-05,4.222794814268127e-05,3.50475893355906e-05,2.6426268959767185e-05,1.6665091607137583e-05,6.112760729592992e-06,-4.846583124162862e-06,-1.580703246872872e-05,-2.6355635782238096e-05,-3.608765109675005e-05,-4.462178549147211e-05,-5.161483568372205e-05,-5.6775195844238624e-05,-5.9874728322029114e-05,-6.075845521991141e-05,-5.9351776144467294e-05,-5.566478648688644e-05,-4.9793565267464146e-05,-4.191825428279117e-05,-3.229797584936023e-05,-2.1262672817101702e-05,-9.202181900036521e-06,3.4472138850105694e-06,1.6218216842389666e-05,2.8629447115235962e-05,4.020325650344603e-05,5.048379171057604e-05,5.905460784561001e-05,6.555520667461678e-05,6.969580135773867e-05,7.126978016458452e-05,7.016327435849234e-05,6.636147008975968e-05,5.99513114138972e-05,5.112045255373232e-05,4.015236481791362e-05,2.741770731518045e-05,1.3362243407755159e-05,-1.5083761581990984e-06,-1.6646430594846606e-05,-3.1481940823141485e-05,-4.544377952697687e-05,-5.7981302234111354e-05,-6.858569395262748e-05,-7.681024726480246e-05,-8.228865772252902e-05,-8.475088543491438e-05,-8.403546962654218e-05,-8.009820885490626e-05,-7.301654113689438e-05,-6.298931111814454e-05,-5.0332091632299125e-05,-3.546774678397924e-05,-1.8912876839749515e-05,-1.2602899914782029e-06,1.68418246175861e-05,3.4713295463006943e-05,5.166716800886206e-05,6.703568215016276e-05,8.019622327992693e-05,9.059608419192955e-05,9.777513332664967e-05,0.0001013855726341717,0.00010120773367816582,9.716148633742705e-05,8.931251068133861e-05,7.787316280882806e-05,6.31977673037909e-05,4.577239815262146e-05,2.6199331841780804e-05,5.176740614842856e-06,-1.6525742466910742e-05,-3.8094793126219884e-05,-5.870347740710713e-05,-7.75425141910091e-05,-9.385165321873501e-05,-0.00010694986121961847,-0.00011626315244939178,-0.00012134906137362123,-0.00012191656423965469,-0.00011784068919951096,-0.0001091711237677373,-9.613432484911755e-05,-7.912890578154474e-05,-5.871430767001584e-05,-3.5593126085586846e-05,-1.0587441465759184e-05,1.5389892723760568e-05,4.136811548960395e-05,6.63544051349163e-05,8.937136590247974e-05,0.00010949481657007709,0.0001258903503185138,0.0001378473243676126,0.00014480884419754148,0.00014639663277193904,0.0001424294023308903,0.0001329343649558723,0.00011815075413323939,9.852551738731563e-05,7.470077252946794e-05,4.7493635065620765e-05,1.7868778741103597e-05,-1.3095179383526556e-05,-4.42444761574734e-05,-7.439272303599864e-05,-0.0001023655931930989,-0.0001270461070816964,-0.00014741862833034247,-0.0001626100274734199,-0.00017192620725836605,-0.00017488267621956766,-0.00017122765711974353,-0.00016095676983240992,-0.00014431861927732825,-0.0001218108445755206,-9.416635293746367e-05,-6.233046588022262e-05,-2.742918331932742e-05,9.269940164813306e-06,4.640332917915657e-05,8.256153523689136e-05,0.00011634224210865796,0.00014640406880062073,0.00017151930660475045,0.0001906232937471941,0.00020285864593461156,0.00020761250925716013,0.0002045452274614945,0.00019360905571375042,0.00017505610594525933,0.00014943511632736772,0.00011757663742173463,8.056697697611526e-05,3.97122094000224e-05,-3.507441306282999e-06,-4.749055369757116e-05,-9.057331044459715e-05,-0.00013109188876114786,-0.00016744615277275443,-0.00019816217536572367,-0.0002219512825831771,-0.00023776321904733777,-0.0002448310551699251,-0.0002427064609946683,-0.0002312833967152983,-0.0002108089829562232,-0.00018188128888141364,-0.00014543358702212572,-0.00010270532220602036,-5.520096601685509e-05,-4.637734491552692e-06,4.7115838242461905e-05,9.810831397771835e-05,0.0001463783992221579,0.00019002967746928334,0.00022730455384589732,0.00025665407883934677,0.00027680149651132524,0.00028679624665528536,0.0002860570093616843,0.00027440080884844065,0.00025205829297192395,0.0002196726418333128,0.00017828318232204765,0.0001292933739023283,7.442427158821374e-05,1.5654773960704915e-05,-4.484888995648362e-05,-0.00010481244680704549,-0.00016193834017030895,-0.0002139932184945792,-0.00025889434618875384,-0.00029479232034645975,-0.00032014588941819966,-0.00033378711668774486,-0.0003349727485328913,-0.0003234210016671568,-0.00029933080077171326,-0.00026338346651755273,-0.00021672570437658578,-0.00016093453450594097,-9.796526137506589e-05,-3.008376734214835e-05,4.0214181353803724e-05,0.00011029396409867331,0.00017748016398400068,0.00023915793281048536,0.0002928740286733955,0.0003364334988873452,0.00036798822111450136,0.00038611391209997237,0.0003898722934536636,0.0003788558824453503,0.00035321328323334455,0.0003136536688543856,0.00026142995920963585,0.00019830091332551092,0.0001264733000425622,4.852561323787086e-05,-3.2683394238119945e-05,-0.00011411886953283101,-0.00019268244795966893,-0.0002653293777257204,-0.00032918559736572206,-0.0003816606476902962,-0.00042055128142237663,-0.0004441328055690974,-0.00045123323798179626,-0.0004412879061419517,-0.0004143719270359725,-0.00037120835622772574,-0.0003131526755169034,-0.0002421517128823325,-0.0001606802543392405,-7.165578426793218e-05,2.166493322874885e-05,0.00011580408317968249,0.0002071915369015187,0.00029229934443719685,0.0003677771601360291,0.00043058276060037315,0.0004781037278007716,0.0005082644056528807,0.0005196143756620586,0.0005113946390338242,0.00048357833293266594,0.00043688484583981335,0.00037276491639204323,0.0002933581417892128,0.00020142318680882454,0.00010024345829151571,-6.489129646070069e-06,-0.00011480779357952997,-0.00022061736672185361,-0.0003198480699211359,-0.0004086109984200448,-0.0004833496641367674,-0.0005409806617535651,-0.0005790196591988206,-0.0005956859095022082,-0.0005899821408092976,-0.0005617457791231573,-0.0005116694374009967,-0.0004412887501530349,-0.0003529381356202066,-0.00024967562058009207,-0.00013517819752451032,-1.3612544535135385e-05,0.00011051564069930464,0.00023252743994817138,0.0003477460122667253,0.00045167465577833354,0.0005401710513979197,0.0006096108118072152,0.0006570342811755836,0.0006802700809203088,0.0006780311814509332,0.0006499781738966703,0.0005967483739368618,0.0005199473816901445,0.0004221044364385307,0.0003065911587327719,0.00017750739061739296,3.953694977099076e-05,-0.00010222068522125483,-0.0002424377016723156,-0.00037575687747448683,-0.000496994995046407,-0.0006013428210280836,-0.0006845541065558791,-0.0007431168924085796,-0.0007743987953290343,-0.0007767612696625292,-0.0007496392354369164,-0.0006935789715498686,-0.000610236544162035,-0.0005023324629291892,-0.0003735658247023821,-0.0002284896036144346,-7.235139491967857e-05,8.909466123441234e-05,0.00024979852605611086,0.00040363945299759507,0.000544657523278147,0.0006672830204479396,0.0007665543234907091,0.000838316569570452,0.000879392959177494,0.0008877210784703493,0.0008624499896541238,0.0008039913955144584,0.0007140254601836205,0.000595457386225462,0.0004523264360614121,0.0002896712685469538,0.00011335470480844378,-7.0145761128515e-05,-0.00025397416902706027,-0.0004311504017096013,-0.0005948334583081305,-0.000738583505153656,-0.0008566132164560258,-0.0009440184803679585,-0.0009969783714041114,-0.00101291888859123,-0.0009906302439048886,-0.0009303353726863861,-0.0008337045437656343,-0.0007038158364593983,-0.0005450608441606164,-0.00036299932980909944,-0.0001641672133700922,4.415596049511805e-05,0.00025421116151846945,0.0004580467939376831,0.0006478174473159015,0.0008160833967849612,0.0009561002952978015,0.0010620857356116176,0.001129455049522221,0.001155015197582543,0.0011371077271178365,0.0010756980627775192,0.0009724030969664454,0.0008304563234560192,0.0006546121439896524,0.00045099033741280437,0.00022686632291879505,-9.586061423760839e-06,-0.0002495899680070579,-0.00048408855218440294,-0.0007040841155685484,-0.0009009803179651499,-0.001066915225237608,-0.0011950716143473983,-0.0012799528194591403,-0.0013176135253161192,-0.00130583462305367,-0.0012442368315532804,-0.0011343249352648854,-0.0009794628713279963,-0.0007847768720239401,-0.0005569903878495097,-0.000304196059005335,-3.5571873013395816e-05,0.00023894886544439942,0.0005090412450954318,0.0007643737480975688,0.0009949997765943408,0.001191741437651217,0.0013465500669553876,0.0014528307365253568,0.0015057175187394023,0.0015022862935438752,0.0014416995691135526,0.001325273304246366,0.0011564649175852537,0.0009407778270542622,0.0006855888641439378,0.0003999012697022408,9.403097647009417e-05,-0.00022076087770983577,-0.0005326782702468336,-0.0008298279717564583,-0.0011006681015715003,-0.0013344516046345234,-0.001521647209301591,-0.0016543215606361628,-0.0017264685593545437,-0.001734269200824201,-0.0016762771410867572,-0.0015535139245912433,-0.0013694751542061567,-0.0011300420155748725,-0.0008433019393123686,-0.0005192816024646163,-0.00016960306675173342,0.00019292772049084306,0.0005547836190089583,0.0009022150188684464,0.0012217662297189236,0.0015007894253358245,0.0017279385356232524,0.0018936221022158861,0.0019903986249119043,0.0020132979843765497,0.0019600552041083574,0.0018312482861801982,0.0016303275479003787,0.0013635414652526379,0.0010397526202723384,0.0006701527163386345,0.00026788428658619523,-0.00015241843357216567,-0.0005751538556069136,-0.0009843235602602363,-0.0013641288969665766,-0.0016995714977383614,-0.001977035775780678,-0.002184830605983734,-0.0023136672098189592,-0.0023570600897073746,-0.0023116266820579767,-0.002177277347072959,-0.001957286149263382,-0.0016582341631874442,-0.0012898308923467994,-0.0008646109490655363,-0.0003975199069827795,9.459911234444007e-05,0.0005936007364653051,0.0010806942591443658,0.0015371377812698483,0.0019449461251497269,0.0022875843569636345,0.0025506215170025826,0.002722320379689336,0.0027941374573856592,0.002761115552857518,0.0026221477892249823,0.00238010729663074,0.00204182555899024,0.0016179264057427645,0.0011225113412365317,0.0005727094248868525,-1.1897291187779047e-05,-0.0006099528400227427,-0.0011990881757810712,-0.0017567375907674432,-0.002260981360450387,-0.002691384172067046,-0.0030297967605292797,-0.003261093981564045,-0.003373813582584262,-0.0033606786746531725,-0.0032189725898206234,-0.002950755413621664,-0.002562908921390772,-0.002066999673843384,-0.001478968420997262,-0.0008186470367945731,-0.00010911887511610985,0.0006240576622076333,0.0013537377817556262,0.0020521609112620354,0.0026919699739664793,0.003247241722419858,0.0036944944877177477,0.004013630095869303,0.004188778810203075,0.004209010396152735,0.00406888360157609,0.003768809838220477,0.0033152110408991575,0.002720460295677185,0.0020026061683893204,0.0011848759604617953,0.0002949776826426387,-0.0006357831880450249,-0.0015735458582639694,-0.002483061049133539,-0.0033289450220763683,-0.004076977260410786,-0.004695397801697254,-0.0051561580039560795,-0.0054360744543373585,-0.0055178492330014706,-0.00539091182872653,-0.005052041262388229,-0.004505757242441177,-0.0037644372787326574,-0.0028481632471084595,-0.0017842868110165,-0.0006067223730497062,0.0006450195796787739,0.001927029574289918,0.003192397067323327,0.004392764065414667,0.0054799895733594894,0.006407868582755327,0.007133854553103447,0.007620718330144882,0.007838095538318157,0.007763860747218132,0.007385279983282089,0.006699894089251757,0.005716097075492144,0.004453381057828665,0.002942227991297841,0.0012236412148922682,-0.0006516797002404928,-0.002624502871185541,-0.004628542345017195,-0.0065922122448682785,-0.008440607227385044,-0.010097658261656761,-0.011488398537039757,-0.012541267089545727,-0.01319038961082697,-0.013377759605646133,-0.013055249117314816,-0.012186398729681969,-0.010747890919446945,-0.008730705827474594,-0.006140877027064562,-0.0029998307581990957,0.0006557011511176825,0.004774217493832111,0.009290412068367004,0.014126549474895,0.019194221124053,0.024396434426307678,0.029629969969391823,0.03478796407580376,0.03976261988282204,0.04444798827171326,0.048742715269327164,0.052552737295627594,0.05579373240470886,0.05839340388774872,0.06029339134693146,0.06145085394382477,0.06183960661292076,0.06145085394382477,0.06029339134693146,0.05839340388774872,0.05579373240470886,0.052552737295627594,0.048742715269327164,0.04444798827171326,0.03976261988282204,0.03478796407580376,0.029629969969391823,0.024396434426307678,0.019194221124053,0.014126549474895,0.009290412068367004,0.004774217493832111,0.0006557011511176825,-0.0029998307581990957,-0.006140877027064562,-0.008730705827474594,-0.010747890919446945,-0.012186398729681969,-0.013055249117314816,-0.013377759605646133,-0.01319038961082697,-0.012541267089545727,-0.011488398537039757,-0.010097658261656761,-0.008440607227385044,-0.0065922122448682785,-0.004628542345017195,-0.002624502871185541,-0.0006516797002404928,0.0012236412148922682,0.002942227991297841,0.004453381057828665,0.005716097075492144,0.006699894089251757,0.007385279983282089,0.007763860747218132,0.007838095538318157,0.007620718330144882,0.007133854553103447,0.006407868582755327,0.0054799895733594894,0.004392764065414667,0.003192397067323327,0.001927029574289918,0.0006450195796787739,-0.0006067223730497062,-0.0017842868110165,-0.0028481632471084595,-0.0037644372787326574,-0.004505757242441177,-0.005052041262388229,-0.00539091182872653,-0.0055178492330014706,-0.0054360744543373585,-0.0051561580039560795,-0.004695397801697254,-0.004076977260410786,-0.0033289450220763683,-0.002483061049133539,-0.0015735458582639694,-0.0006357831880450249,0.0002949776826426387,0.0011848759604617953,0.0020026061683893204,0.002720460295677185,0.0033152110408991575,0.003768809838220477,0.00406888360157609,0.004209010396152735,0.004188778810203075,0.004013630095869303,0.0036944944877177477,0.003247241722419858,0.0026919699739664793,0.0020521609112620354,0.0013537377817556262,0.0006240576622076333,-0.00010911887511610985,-0.0008186470367945731,-0.001478968420997262,-0.002066999673843384,-0.002562908921390772,-0.002950755413621664,-0.0032189725898206234,-0.0033606786746531725,-0.003373813582584262,-0.003261093981564045,-0.0030297967605292797,-0.002691384172067046,-0.002260981360450387,-0.0017567375907674432,-0.0011990881757810712,-0.0006099528400227427,-1.1897291187779047e-05,0.0005727094248868525,0.0011225113412365317,0.0016179264057427645,0.00204182555899024,0.00238010729663074,0.0026221477892249823,0.002761115552857518,0.0027941374573856592,0.002722320379689336,0.0025506215170025826,0.0022875843569636345,0.0019449461251497269,0.0015371377812698483,0.0010806942591443658,0.0005936007364653051,9.459911234444007e-05,-0.0003975199069827795,-0.0008646109490655363,-0.0012898308923467994,-0.0016582341631874442,-0.001957286149263382,-0.002177277347072959,-0.0023116266820579767,-0.0023570600897073746,-0.0023136672098189592,-0.002184830605983734,-0.001977035775780678,-0.0016995714977383614,-0.0013641288969665766,-0.0009843235602602363,-0.0005751538556069136,-0.00015241843357216567,0.00026788428658619523,0.0006701527163386345,0.0010397526202723384,0.0013635414652526379,0.0016303275479003787,0.0018312482861801982,0.0019600552041083574,0.0020132979843765497,0.0019903986249119043,0.0018936221022158861,0.0017279385356232524,0.0015007894253358245,0.0012217662297189236,0.0009022150188684464,0.0005547836190089583,0.00019292772049084306,-0.00016960306675173342,-0.0005192816024646163,-0.0008433019393123686,-0.0011300420155748725,-0.0013694751542061567,-0.0015535139245912433,-0.0016762771410867572,-0.001734269200824201,-0.0017264685593545437,-0.0016543215606361628,-0.001521647209301591,-0.0013344516046345234,-0.0011006681015715003,-0.0008298279717564583,-0.0005326782702468336,-0.00022076087770983577,9.403097647009417e-05,0.0003999012697022408,0.0006855888641439378,0.0009407778270542622,0.0011564649175852537,0.001325273304246366,0.0014416995691135526,0.0015022862935438752,0.0015057175187394023,0.0014528307365253568,0.0013465500669553876,0.001191741437651217,0.0009949997765943408,0.0007643737480975688,0.0005090412450954318,0.00023894886544439942,-3.5571873013395816e-05,-0.000304196059005335,-0.0005569903878495097,-0.0007847768720239401,-0.0009794628713279963,-0.0011343249352648854,-0.0012442368315532804,-0.00130583462305367,-0.0013176135253161192,-0.0012799528194591403,-0.0011950716143473983,-0.001066915225237608,-0.0009009803179651499,-0.0007040841155685484,-0.00048408855218440294,-0.0002495899680070579,-9.586061423760839e-06,0.00022686632291879505,0.00045099033741280437,0.0006546121439896524,0.0008304563234560192,0.0009724030969664454,0.0010756980627775192,0.0011371077271178365,0.001155015197582543,0.001129455049522221,0.0010620857356116176,0.0009561002952978015,0.0008160833967849612,0.0006478174473159015,0.0004580467939376831,0.00025421116151846945,4.415596049511805e-05,-0.0001641672133700922,-0.00036299932980909944,-0.0005450608441606164,-0.0007038158364593983,-0.0008337045437656343,-0.0009303353726863861,-0.0009906302439048886,-0.00101291888859123,-0.0009969783714041114,-0.0009440184803679585,-0.0008566132164560258,-0.000738583505153656,-0.0005948334583081305,-0.0004311504017096013,-0.00025397416902706027,-7.0145761128515e-05,0.00011335470480844378,0.0002896712685469538,0.0004523264360614121,0.000595457386225462,0.0007140254601836205,0.0008039913955144584,0.0008624499896541238,0.0008877210784703493,0.000879392959177494,0.000838316569570452,0.0007665543234907091,0.0006672830204479396,0.000544657523278147,0.00040363945299759507,0.00024979852605611086,8.909466123441234e-05,-7.235139491967857e-05,-0.0002284896036144346,-0.0003735658247023821,-0.0005023324629291892,-0.000610236544162035,-0.0006935789715498686,-0.0007496392354369164,-0.0007767612696625292,-0.0007743987953290343,-0.0007431168924085796,-0.0006845541065558791,-0.0006013428210280836,-0.000496994995046407,-0.00037575687747448683,-0.0002424377016723156,-0.00010222068522125483,3.953694977099076e-05,0.00017750739061739296,0.0003065911587327719,0.0004221044364385307,0.0005199473816901445,0.0005967483739368618,0.0006499781738966703,0.0006780311814509332,0.0006802700809203088,0.0006570342811755836,0.0006096108118072152,0.0005401710513979197,0.00045167465577833354,0.0003477460122667253,0.00023252743994817138,0.00011051564069930464,-1.3612544535135385e-05,-0.00013517819752451032,-0.00024967562058009207,-0.0003529381356202066,-0.0004412887501530349,-0.0005116694374009967,-0.0005617457791231573,-0.0005899821408092976,-0.0005956859095022082,-0.0005790196591988206,-0.0005409806617535651,-0.0004833496641367674,-0.0004086109984200448,-0.0003198480699211359,-0.00022061736672185361,-0.00011480779357952997,-6.489129646070069e-06,0.00010024345829151571,0.00020142318680882454,0.0002933581417892128,0.00037276491639204323,0.00043688484583981335,0.00048357833293266594,0.0005113946390338242,0.0005196143756620586,0.0005082644056528807,0.0004781037278007716,0.00043058276060037315,0.0003677771601360291,0.00029229934443719685,0.0002071915369015187,0.00011580408317968249,2.166493322874885e-05,-7.165578426793218e-05,-0.0001606802543392405,-0.0002421517128823325,-0.0003131526755169034,-0.00037120835622772574,-0.0004143719270359725,-0.0004412879061419517,-0.00045123323798179626,-0.0004441328055690974,-0.00042055128142237663,-0.0003816606476902962,-0.00032918559736572206,-0.0002653293777257204,-0.00019268244795966893,-0.00011411886953283101,-3.2683394238119945e-05,4.852561323787086e-05,0.0001264733000425622,0.00019830091332551092,0.00026142995920963585,0.0003136536688543856,0.00035321328323334455,0.0003788558824453503,0.0003898722934536636,0.00038611391209997237,0.00036798822111450136,0.0003364334988873452,0.0002928740286733955,0.00023915793281048536,0.00017748016398400068,0.00011029396409867331,4.0214181353803724e-05,-3.008376734214835e-05,-9.796526137506589e-05,-0.00016093453450594097,-0.00021672570437658578,-0.00026338346651755273,-0.00029933080077171326,-0.0003234210016671568,-0.0003349727485328913,-0.00033378711668774486,-0.00032014588941819966,-0.00029479232034645975,-0.00025889434618875384,-0.0002139932184945792,-0.00016193834017030895,-0.00010481244680704549,-4.484888995648362e-05,1.5654773960704915e-05,7.442427158821374e-05,0.0001292933739023283,0.00017828318232204765,0.0002196726418333128,0.00025205829297192395,0.00027440080884844065,0.0002860570093616843,0.00028679624665528536,0.00027680149651132524,0.00025665407883934677,0.00022730455384589732,0.00019002967746928334,0.0001463783992221579,9.810831397771835e-05,4.7115838242461905e-05,-4.637734491552692e-06,-5.520096601685509e-05,-0.00010270532220602036,-0.00014543358702212572,-0.00018188128888141364,-0.0002108089829562232,-0.0002312833967152983,-0.0002427064609946683,-0.0002448310551699251,-0.00023776321904733777,-0.0002219512825831771,-0.00019816217536572367,-0.00016744615277275443,-0.00013109188876114786,-9.057331044459715e-05,-4.749055369757116e-05,-3.507441306282999e-06,3.97122094000224e-05,8.056697697611526e-05,0.00011757663742173463,0.00014943511632736772,0.00017505610594525933,0.00019360905571375042,0.0002045452274614945,0.00020761250925716013,0.00020285864593461156,0.0001906232937471941,0.00017151930660475045,0.00014640406880062073,0.00011634224210865796,8.256153523689136e-05,4.640332917915657e-05,9.269940164813306e-06,-2.742918331932742e-05,-6.233046588022262e-05,-9.416635293746367e-05,-0.0001218108445755206,-0.00014431861927732825,-0.00016095676983240992,-0.00017122765711974353,-0.00017488267621956766,-0.00017192620725836605,-0.0001626100274734199,-0.00014741862833034247,-0.0001270461070816964,-0.0001023655931930989,-7.439272303599864e-05,-4.42444761574734e-05,-1.3095179383526556e-05,1.7868778741103597e-05,4.7493635065620765e-05,7.470077252946794e-05,9.852551738731563e-05,0.00011815075413323939,0.0001329343649558723,0.0001424294023308903,0.00014639663277193904,0.00014480884419754148,0.0001378473243676126,0.0001258903503185138,0.00010949481657007709,8.937136590247974e-05,6.63544051349163e-05,4.136811548960395e-05,1.5389892723760568e-05,-1.0587441465759184e-05,-3.5593126085586846e-05,-5.871430767001584e-05,-7.912890578154474e-05,-9.613432484911755e-05,-0.0001091711237677373,-0.00011784068919951096,-0.00012191656423965469,-0.00012134906137362123,-0.00011626315244939178,-0.00010694986121961847,-9.385165321873501e-05,-7.75425141910091e-05,-5.870347740710713e-05,-3.8094793126219884e-05,-1.6525742466910742e-05,5.176740614842856e-06,2.6199331841780804e-05,4.577239815262146e-05,6.31977673037909e-05,7.787316280882806e-05,8.931251068133861e-05,9.716148633742705e-05,0.00010120773367816582,0.0001013855726341717,9.777513332664967e-05,9.059608419192955e-05,8.019622327992693e-05,6.703568215016276e-05,5.166716800886206e-05,3.4713295463006943e-05,1.68418246175861e-05,-1.2602899914782029e-06,-1.8912876839749515e-05,-3.546774678397924e-05,-5.0332091632299125e-05,-6.298931111814454e-05,-7.301654113689438e-05,-8.009820885490626e-05,-8.403546962654218e-05,-8.475088543491438e-05,-8.228865772252902e-05,-7.681024726480246e-05,-6.858569395262748e-05,-5.7981302234111354e-05,-4.544377952697687e-05,-3.1481940823141485e-05,-1.6646430594846606e-05,-1.5083761581990984e-06,1.3362243407755159e-05,2.741770731518045e-05,4.015236481791362e-05,5.112045255373232e-05,5.99513114138972e-05,6.636147008975968e-05,7.016327435849234e-05,7.126978016458452e-05,6.969580135773867e-05,6.555520667461678e-05,5.905460784561001e-05,5.048379171057604e-05,4.020325650344603e-05,2.8629447115235962e-05,1.6218216842389666e-05,3.4472138850105694e-06,-9.202181900036521e-06,-2.1262672817101702e-05,-3.229797584936023e-05,-4.191825428279117e-05,-4.9793565267464146e-05,-5.566478648688644e-05,-5.9351776144467294e-05,-6.075845521991141e-05,-5.9874728322029114e-05,-5.6775195844238624e-05,-5.161483568372205e-05,-4.462178549147211e-05,-3.608765109675005e-05,-2.6355635782238096e-05,-1.580703246872872e-05,-4.846583124162862e-06,6.112760729592992e-06,1.6665091607137583e-05,2.6426268959767185e-05,3.50475893355906e-05,4.222794814268127e-05,4.7724039177410305e-05,5.1358292694203556e-05,5.302433419274166e-05,5.268970562610775e-05,5.039593088440597e-05,4.625586370821111e-05,4.044852903462015e-05,3.32115960191004e-05,2.4831948394421488e-05,1.563448313390836e-05,5.9698168115573935e-06,-3.798832949541975e-06,-1.3309011592355091e-05,-2.2212188923731446e-05,-3.0186249205144122e-05,-3.69468834833242e-05,-4.225744123687036e-05,-4.593699850374833e-05,-4.786629506270401e-05,-4.799141606781632e-05,-4.632502168533392e-05,-4.294529207982123e-05,-3.799239493673667e-05,-3.166286478517577e-05,-2.4201965061365627e-05,-1.5894376701908186e-05,-7.053566605463857e-06,1.989800921364804e-06,1.0899972949118819e-05,1.9348311980138533e-05,2.702515121200122e-05,3.365090742590837e-05,3.8986032450338826e-05,4.2839470552280545e-05,4.5075368689140305e-05,4.5617685827892274e-05]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30.72e6
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/10000
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: dsp.generate_tx_samples(0,25)
  states: {}
- name: eventhubs_zc_detector_0
  id: eventhubs_zc_detector
  parameters:
    chan_idx: '0'
    threshold: '0.35'
    zc_root: '25'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: np.conjugate(dsp.gen_ZC(25))[::-1]
    type: ccc
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: (dsp.FFT_SAMP_RATE) * -7.5
    decim: '16'
    samp_rate: samp_rate
    taps: lpftaps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import dsp
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/16
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '256'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/16
    fc: '0'
    fftsize: '256'
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [eventhubs_zc_detector_0, detections, blocks_message_debug_0, print]
- [fft_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [fft_filter_xxx_0, '0', eventhubs_zc_detector_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', fft_filter_xxx_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1

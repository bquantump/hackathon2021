options:
  parameters:
    generate_options: qt_gui
    id: testrx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ZC_ROOT
  id: variable
  parameters:
    value: '25'
  states: {}
- name: chan_num
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: (dspcore.FFT_SAMP_RATE) * (-7.5 + chan_num)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30.72e6
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 1.9e6/2
    gain: '1.0'
    samp_rate: samp_rate
    width: 250e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: eventhub_detect_sink_0
  id: eventhub_detect_sink
  parameters:
    connection_str: os.environ["EVENTHUB_CONNECTION_STRING"]
    endpoint: os.environ['EVENTHUB_HOSTNAME']
    eventhub_name: os.environ['EVENTHUB_DETECT_CONSUMER_TOPIC_NAME']
    schema_group: os.environ['SCHEMA_REGISTRY_GROUP']
  states: {}
- name: eventhub_detect_source_0
  id: eventhub_detect_source
  parameters:
    connection_str: os.environ["EVENTHUB_CONNECTION_STRING"]
    consumer_group: '"$Default"'
    endpoint: os.environ['EVENTHUB_HOSTNAME']
    eventhub_name: os.environ['EVENTHUB_DETECT_CONSUMER_TOPIC_NAME']
    schema_group: os.environ['SCHEMA_REGISTRY_GROUP']
    starting_position: '"@latest"'
  states: {}
- name: eventhub_source_0
  id: eventhub_source
  parameters:
    connection_str: os.environ["EVENTHUB_CONNECTION_STRING"]
    consumer_group: '"$Default"'
    endpoint: os.environ['EVENTHUB_HOSTNAME']
    eventhub_name: os.environ['EVENTHUB_RF_CONSUMER_TOPIC_NAME']
    schema_group: os.environ['SCHEMA_REGISTRY_GROUP']
    starting_position: '"@latest"'
  states: {}
- name: eventhubs_zc_detector_0
  id: eventhubs_zc_detector
  parameters:
    chan_idx: chan_num
    threshold: '0'
    zc_root: ZC_ROOT
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: np.conjugate(dspcore.gen_ZC(25))[::-1]
    type: ccc
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: freq_offset
    decim: '16'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import dspcore
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [eventhub_detect_source_0, out, blocks_message_debug_0, print]
- [eventhub_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [eventhub_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [eventhubs_zc_detector_0, detections, blocks_message_debug_0_0, print]
- [eventhubs_zc_detector_0, detections, eventhub_detect_sink_0, in]
- [fft_filter_xxx_0, '0', eventhubs_zc_detector_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', fft_filter_xxx_0, '0']

metadata:
  file_format: 1

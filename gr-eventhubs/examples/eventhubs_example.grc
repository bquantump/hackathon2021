options:
  parameters:
    author: bquantump
    generate_options: qt_gui
    id: testgrc
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 30.72e6 * .001
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: len( [0,0,0,0,0,0,0,0, 0, 0 ,0,0,0,0,0,0,0,0,0])
  states: {}
- name: vec
  id: variable
  parameters:
    value: '[complex(-1,-1), complex(1,-1), complex(-1,1), complex(-1,-1), complex(1,1), complex(-1,-1), complex(-1,1), complex(1,-1), complex(.5, .1), complex(-.3, 1), complex(.9, .2), complex(.3, -1)]*5'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: vec + [0,0,0,0,0,0,0,0, 0, 0 ,0,0,0,0,0,0,0,0,0]*5
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: dspcore.generate_tx_samples(11,25)
  states: {}
- name: eventhub_sink_0
  id: eventhub_sink
  parameters:
    affinity: '2'
    block_len: int(8192*2)
    connection_str: os.environ['EVENTHUB_CONNECTION_STRING']
    endpoint: os.environ['EVENTHUB_HOSTNAME']
    eventhub_name: os.environ['EVENTHUB_CONSUMER_TOPIC_NAME']
    schema_group: os.environ['SCHEMA_REGISTRY_GROUP']
  states: {}
- name: eventhub_source_0
  id: eventhub_source
  parameters:
    affinity: '1'
    connection_str: os.environ['EVENTHUB_CONNECTION_STRING']
    consumer_group: '"$Default"'
    endpoint: os.environ['EVENTHUB_HOSTNAME']
    eventhub_name: os.environ['EVENTHUB_CONSUMER_TOPIC_NAME']
    schema_group: os.environ['SCHEMA_REGISTRY_GROUP']
    starting_position: '"@latest"'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: np.flip(np.conj(vec))
    type: ccc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import dspcore
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 1024*2
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: 1024*2
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    size: 1024*2
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_throttle_0, '0', eventhub_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle_0, '0']
- [eventhub_source_0, '0', blocks_probe_rate_0, '0']
- [eventhub_source_0, '0', fir_filter_xxx_0, '0']
- [eventhub_source_0, '0', qtgui_time_sink_x_0, '0']
- [eventhub_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0_1, '0']

metadata:
  file_format: 1

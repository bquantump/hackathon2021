options:
  parameters:
    author: bquantump
    generate_options: qt_gui
    id: fulleventhub_tx_and_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ZC_ROOT
  id: variable
  parameters:
    value: '25'
  states: {}
- name: chan_num
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: (dspcore.FFT_SAMP_RATE) * (-7.5 + chan_num)
  states: {}
- name: lpf_taps
  id: variable
  parameters:
    value: '[-7.975280459504575e-05, -4.9262958782492206e-05, -1.6447560483356938e-05, 1.775114651536569e-05, 5.2323939598863944e-05, 8.620815060567111e-05, 0.0001183042477350682, 0.00014749598631169647, 0.00017267520888708532, 0.00019277109822724015, 0.00020678412693087012, 0.00021382409613579512, 0.00021315101184882224, 0.00020421782392077148, 0.00018671243742574006, 0.00016059722111094743, 0.0001261434081243351, 8.395734039368108e-05, 3.499631566228345e-05, -1.9428558516665362e-05, -7.766461203573272e-05, -0.00013774647959508002, -0.0001974424085346982, -0.0002543180307839066, -0.00030581667670048773, -0.00034935466828756034, -0.00038242785376496613, -0.00040272719343192875, -0.00040825686301104724, -0.000397451629396528, -0.0003692862228490412, -0.00032337172888219357, -0.0002600329462438822, -0.00018036100664176047, -8.623716712463647e-05, 1.967684511328116e-05, 0.00013398408191278577, 0.0002526341995690018, 0.0003710418241098523, 0.00048423861153423786, 0.0005870554596185684, 0.0006743291160091758, 0.0007411251426674426, 0.000782970164436847, 0.0007960811490193009, 0.000777584791649133, 0.0007257125107571483, 0.000639963720459491, 0.0005212261457927525, 0.00037184517714194953, 0.00019563482783269137, -2.1731548258685507e-06, -0.0002150458312826231, -0.0004353296826593578, -0.0006544924690388143, -0.0008634199621155858, -0.0010527590056881309, -0.0012132939882576466, -0.0013363448670133948, -0.0014141680439934134, -0.001440347288735211, -0.0014101533452048898, -0.0013208562741056085, -0.0011719767935574055, -0.0009654563618823886, -0.0007057401817291975, -0.0003997587482444942, -5.680566391674802e-05, 0.000311691255774349, 0.0006925018969923258, 0.0010710213100537658, 0.0014317813329398632, 0.0017590289935469627, 0.0020373535808175802, 0.002252337522804737, 0.00239120633341372, 0.0024434514343738556, 0.002401400124654174, 0.0022606998682022095, 0.002020700369030237, 0.0016847088700160384, 0.001260098535567522, 0.0007582596153952181, 0.00019438723393250257, -0.00041289726505056024, -0.001042083720676601, -0.0016694576479494572, -0.002269912511110306, -0.0028178647626191378, -0.0032882390078157187, -0.0036574925761669874, -0.003904638346284628, -0.0040122224017977715, -0.003967225085943937, -0.0037618353962898254, -0.003394069615751505, -0.0028681978583335876, -0.002194953616708517, -0.0013915060553699732, -0.00048118302947841585, 0.0005070575280115008, 0.0015393999638035893, 0.0025781728327274323, 0.003583052661269903, 0.004512437153607607, 0.005324941594153643, 0.005980979185551405, 0.006444355472922325, 0.006683837156742811, 0.00667462358251214, 0.006399671547114849, 0.005850816145539284, 0.005029634106904268, 0.003948013298213482, 0.0026283967308700085, 0.0011036653304472566, -0.0005833368049934506, -0.002380644902586937, -0.004228364676237106, -0.006060187239199877, -0.007805192843079567, -0.009389887563884258, -0.010740415193140507, -0.011784891597926617, -0.012455755844712257, -0.012692097574472427, -0.012441863305866718, -0.011663862504065037, -0.01032952219247818, -0.008424297906458378, -0.005948714446276426, -0.002918964484706521, 0.0006329383468255401, 0.00465948972851038, 0.009098498150706291, 0.0138743557035923, 0.01889972947537899, 0.024077655747532845, 0.02930395118892193, 0.03446989879012108, 0.03946511074900627, 0.04418047145009041, 0.048511143773794174, 0.052359405905008316, 0.0556374192237854, 0.05826963856816292, 0.06019497662782669, 0.06136851757764816, 0.06176277622580528, 0.06136851757764816, 0.06019497662782669, 0.05826963856816292, 0.0556374192237854, 0.052359405905008316, 0.048511143773794174, 0.04418047145009041, 0.03946511074900627, 0.03446989879012108, 0.02930395118892193, 0.024077655747532845, 0.01889972947537899, 0.0138743557035923, 0.009098498150706291, 0.00465948972851038, 0.0006329383468255401, -0.002918964484706521, -0.005948714446276426, -0.008424297906458378, -0.01032952219247818, -0.011663862504065037, -0.012441863305866718, -0.012692097574472427, -0.012455755844712257, -0.011784891597926617, -0.010740415193140507, -0.009389887563884258, -0.007805192843079567, -0.006060187239199877, -0.004228364676237106, -0.002380644902586937, -0.0005833368049934506, 0.0011036653304472566, 0.0026283967308700085, 0.003948013298213482, 0.005029634106904268, 0.005850816145539284, 0.006399671547114849, 0.00667462358251214, 0.006683837156742811, 0.006444355472922325, 0.005980979185551405, 0.005324941594153643, 0.004512437153607607, 0.003583052661269903, 0.0025781728327274323, 0.0015393999638035893, 0.0005070575280115008, -0.00048118302947841585, -0.0013915060553699732, -0.002194953616708517, -0.0028681978583335876, -0.003394069615751505, -0.0037618353962898254, -0.003967225085943937, -0.0040122224017977715, -0.003904638346284628, -0.0036574925761669874, -0.0032882390078157187, -0.0028178647626191378, -0.002269912511110306, -0.0016694576479494572, -0.001042083720676601, -0.00041289726505056024, 0.00019438723393250257, 0.0007582596153952181, 0.001260098535567522, 0.0016847088700160384, 0.002020700369030237, 0.0022606998682022095, 0.002401400124654174, 0.0024434514343738556, 0.00239120633341372, 0.002252337522804737, 0.0020373535808175802, 0.0017590289935469627, 0.0014317813329398632, 0.0010710213100537658, 0.0006925018969923258, 0.000311691255774349, -5.680566391674802e-05, -0.0003997587482444942, -0.0007057401817291975, -0.0009654563618823886, -0.0011719767935574055, -0.0013208562741056085, -0.0014101533452048898, -0.001440347288735211, -0.0014141680439934134, -0.0013363448670133948, -0.0012132939882576466, -0.0010527590056881309, -0.0008634199621155858, -0.0006544924690388143, -0.0004353296826593578, -0.0002150458312826231, -2.1731548258685507e-06, 0.00019563482783269137, 0.00037184517714194953, 0.0005212261457927525, 0.000639963720459491, 0.0007257125107571483, 0.000777584791649133, 0.0007960811490193009, 0.000782970164436847, 0.0007411251426674426, 0.0006743291160091758, 0.0005870554596185684, 0.00048423861153423786, 0.0003710418241098523, 0.0002526341995690018, 0.00013398408191278577, 1.967684511328116e-05, -8.623716712463647e-05, -0.00018036100664176047, -0.0002600329462438822, -0.00032337172888219357, -0.0003692862228490412, -0.000397451629396528, -0.00040825686301104724, -0.00040272719343192875, -0.00038242785376496613, -0.00034935466828756034, -0.00030581667670048773, -0.0002543180307839066, -0.0001974424085346982, -0.00013774647959508002, -7.766461203573272e-05, -1.9428558516665362e-05, 3.499631566228345e-05, 8.395734039368108e-05, 0.0001261434081243351, 0.00016059722111094743, 0.00018671243742574006, 0.00020421782392077148, 0.00021315101184882224, 0.00021382409613579512, 0.00020678412693087012, 0.00019277109822724015, 0.00017267520888708532, 0.00014749598631169647, 0.0001183042477350682, 8.620815060567111e-05, 5.2323939598863944e-05, 1.775114651536569e-05, -1.6447560483356938e-05, -4.9262958782492206e-05, -7.975280459504575e-05]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '30.72e6 '
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '.01'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: len(np.conjugate(dspcore.gen_ZC(25))[::-1])
    type: complex
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 300e3/1
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: dspcore.generate_tx_samples(8,25)
  states: {}
- name: eventhub_detect_sink_0
  id: eventhub_detect_sink
  parameters:
    connection_str: os.environ["EVENTHUB_CONNECTION_STRING"]
    endpoint: os.environ['EVENTHUB_HOSTNAME']
    eventhub_name: os.environ['EVENTHUB_DETECT_CONSUMER_TOPIC_NAME']
    schema_group: os.environ['SCHEMA_REGISTRY_GROUP']
  states: {state: disabled}
- name: eventhub_detect_source_0
  id: eventhub_detect_source
  parameters:
    connection_str: os.environ["EVENTHUB_CONNECTION_STRING"]
    consumer_group: '"$Default"'
    endpoint: os.environ['EVENTHUB_HOSTNAME']
    eventhub_name: os.environ['EVENTHUB_DETECT_CONSUMER_TOPIC_NAME']
    schema_group: os.environ['SCHEMA_REGISTRY_GROUP']
    starting_position: '"@latest"'
  states: {}
- name: eventhub_sink_0
  id: eventhub_sink
  parameters:
    affinity: '2'
    block_len: int(8192*2)
    connection_str: os.environ['EVENTHUB_CONNECTION_STRING']
    endpoint: os.environ['EVENTHUB_HOSTNAME']
    eventhub_name: os.environ['EVENTHUB_CONSUMER_TOPIC_NAME']
    schema_group: os.environ['SCHEMA_REGISTRY_GROUP']
  states: {}
- name: eventhub_source_0
  id: eventhub_source
  parameters:
    affinity: '1'
    connection_str: os.environ['EVENTHUB_CONNECTION_STRING']
    consumer_group: '"$Default"'
    endpoint: os.environ['EVENTHUB_HOSTNAME']
    eventhub_name: os.environ['EVENTHUB_CONSUMER_TOPIC_NAME']
    schema_group: os.environ['SCHEMA_REGISTRY_GROUP']
    starting_position: '"@latest"'
  states: {state: disabled}
- name: eventhubs_ofdm_demod_0
  id: eventhubs_ofdm_demod
  parameters:
    threshold: '0.35'
  states: {}
- name: eventhubs_zc_detector_0
  id: eventhubs_zc_detector
  parameters:
    chan_idx: '0'
    threshold: '0.35'
    zc_root: '25'
  states: {state: disabled}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: np.conjugate(dspcore.gen_ZC(25))[::-1]
    type: ccc
  states: {state: disabled}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: np.conjugate(dspcore.gen_ZC(25))[::-1]
    type: ccc
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: freq_offset
    decim: '16'
    samp_rate: samp_rate
    taps: lpf_taps
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '16'
    samp_rate: samp_rate
    taps: lpf_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import dspcore
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_2
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '64'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/16
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"const"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: freqs
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: freqs
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_0_0, '0', eventhubs_ofdm_demod_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_delay_0, '0', eventhubs_ofdm_demod_0, '1']
- [blocks_throttle_0, '0', eventhub_sink_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_add_xx_0, '0']
- [eventhub_detect_source_0, out, eventhubs_ofdm_demod_0, detections]
- [eventhub_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [eventhubs_ofdm_demod_0, '0', qtgui_const_sink_x_0, '0']
- [eventhubs_ofdm_demod_0, '0', qtgui_time_sink_x_1, '0']
- [eventhubs_ofdm_demod_0, freq, virtual_sink_0, '0']
- [eventhubs_zc_detector_0, detections, eventhub_detect_sink_0, in]
- [fft_filter_xxx_0, '0', eventhubs_zc_detector_0, '0']
- [fft_filter_xxx_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', fft_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_delay_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', fft_filter_xxx_0_0, '0']
- [virtual_source_0, '0', blocks_message_debug_0_0, print]
- [virtual_source_0, '0', fft_filter_xxx_0_0, taps]
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0, freq]

metadata:
  file_format: 1
